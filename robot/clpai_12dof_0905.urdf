Commit message: add RL

File: robot/clpai_12dof_0905.urdf (robot description, URDF)
Before this commit: robot clpai_12dof_0905, 16 links, 15 joints
Links:
- link camera_mount_link: geometry collision box size=0.04 0.04 0.04; visual box size=0.004 0.004 0.004
